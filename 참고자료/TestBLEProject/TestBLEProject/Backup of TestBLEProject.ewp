# IAR project Backup of TestBLEProject.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2541F256.i51
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; xPLUS_BROADCASTER; HAL_LCD=FALSE; HAL_LED=TRUE; CC2540_MINIDK; POWER_SAVING
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\Profiles\Roles; ..\..\Profiles\DevInfo\; ..\Source
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: C:\workspace\8051\BLE-CC254x-1.4.0\Projects\ble\common\cc2540\ti_51ew_cc2540b.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: lnk0t.xcl
  group App
    ../Source/: app_task.c OSAL_TestProject.c TestBLEMain.c
  group BluetoothLeLib
    ../../Libraries/CC2541DB/bin/: CC2541_BLE_peri.lib
    ../../Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group HAL/Common
    ../../../../Components/hal/common/: hal_drivers.c
  group HAL/Driver
    ../../../../Components/hal/target/CC2540EB/: hal_adc.c hal_aes.c hal_crc.c hal_dma.c hal_flash.c hal_key.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c
  group OSAL
    ../../../../Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../Components/osal/mcu/cc2540/: osal_snv.c
  group Profiles
    ../../Profiles/DevInfo/: devinfoservice.c
    ../../Profiles/Roles/: gap.c gapbondmgr.c peripheral.c
    ../../Include/: gatt_profile_uuid.h
    ../../../../Components/ble/host/: gatt_uuid.c
    ../../Profiles/Keys/: simplekeys.c
  group Tools
    ../../config/: buildComponents.cfg
    ./: buildConfig.cfg
    ../../common/cc2540/: OnBoard.c OnBoard.h
